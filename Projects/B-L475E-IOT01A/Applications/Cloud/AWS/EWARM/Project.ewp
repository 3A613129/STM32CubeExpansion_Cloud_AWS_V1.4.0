# IAR project Project.ewp, settings and files
configuration B-L475E-IOT01_AWS (ARM)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L475xx; USE_HAL_DRIVER; BOOTLOADER; SENSOR; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; AWS; JSMN_PARENT_LINKS; USE_WIFI
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ../../../../../../Drivers/CMSIS/Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ../../../../../../Drivers/BSPv2/B-L475E-IOT01; ..\Inc; ../../../../../../Middlewares/ST/STM32_Connect_Library/Includes; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\BootLoader_OSC\2_Images_SECoreBin\Inc; ..\..\..\BootLoader_OSC\2_Images_SBSFU\SBSFU\App; ..\..\..\BootLoader_OSC\Linker_Common\EWARM; ../../../../../Misc_Utils/Inc; ../../../../../../Utilities/Time; ../../../../../../Utilities/CLD_utils/http_lib; ../../../../../../Middlewares/Third_Party/AWS/samples/STM32Cube; ../../../../../../Middlewares/Third_Party/AWS/platform/STM32Cube; ../../../../../../Middlewares/Third_Party/AWS/include; ../../../../../../Middlewares/Third_Party/mbedTLS/include; ../../../../../../Middlewares/Third_Party/jsmn; ../../../../../../Drivers/BSPv2/Components/es_wifi; ../../../../../../Drivers/BSPv2/Components/vl53l0x; ../../../BootLoader_OSC/Linker_Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: B-L475E-IOT01_AWS.bin
  postbuild: cmd /C  "cmd /C ..\..\..\BootLoader_OSC\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "$TARGET_DIR$\$CONFIG_NAME$.bin" 1 bigelf"
  ILINK.IlinkOutputFile: B-L475E-IOT01.out
  ILINK.IlinkIcfFile: stm32l475xx_flash_for_sfu.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\..\BootLoader_OSC\Linker_Common\EWARM\
  ILINK.IlinkAdditionalLibs: ..\..\..\BootLoader_OSC\2_Images_SBSFU\EWARM\se_interface_appli.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c stm32l4xx_it.c mbedtls_entropy.c stm32l4xx_hal_msp.c flash_l4.c vl53l0x_proximity.c vl53l0x_platform.c net_conf.c
  group Application/AWS
    ../../../../../../Middlewares/Third_Party/AWS/platform/STM32Cube/: aws_network_st_wrapper.c aws_timer.c
    ../../../../../../Middlewares/Third_Party/AWS/samples/STM32Cube/: aws_subscribe_publish_sensor_values.c
  group Application/Utils
    ../../../../../Misc_Utils/Src/: cloud.c iot_flash_config.c rfu.c
    ../Src/: set_credentials.c sensors_data.c
    ../../../../../../Utilities/CLD_utils/http_lib/: http_lib.c
  group Application/Time
    ../../../../../../Utilities/Time/: STM32CubeRTCInterface.c timingSystem.c timedate.c
  group Application/EWARM
    ./: startup_stm32l475xx.s
  group BootLoader
    ../: bootloader_readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components/es_wifi
    ../../../../../../Drivers/BSPv2/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/HTS221
    ../../../../../../Drivers/BSPv2/Components/hts221/: hts221.c hts221_reg.c
  group Drivers/BSP/Components/LIS3MDL
    ../../../../../../Drivers/BSPv2/Components/lis3mdl/: lis3mdl.c lis3mdl_reg.c
  group Drivers/BSP/Components/LPS22HB
    ../../../../../../Drivers/BSPv2/Components/lps22hb/: lps22hb.c lps22hb_reg.c
  group Drivers/BSP/Components/LSM6DSL
    ../../../../../../Drivers/BSPv2/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
  group Drivers/BSP/Components/vl53l0x
    ../../../../../../Drivers/BSPv2/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group Drivers/BSP/B-L475E-IOT01
    ../../../../../../Drivers/BSPv2/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_bus.c stm32l475e_iot01_env_sensors.c stm32l475e_iot01_motion_sensors.c
  group Middlewares/Third_Party/AWS
    ../../../../../../Middlewares/Third_Party/AWS/src/: aws_iot_jobs_interface.c aws_iot_jobs_json.c aws_iot_jobs_topics.c aws_iot_jobs_types.c aws_iot_json_utils.c aws_iot_mqtt_client.c aws_iot_mqtt_client_common_internal.c aws_iot_mqtt_client_connect.c aws_iot_mqtt_client_publish.c aws_iot_mqtt_client_subscribe.c aws_iot_mqtt_client_unsubscribe.c aws_iot_mqtt_client_yield.c aws_iot_shadow.c aws_iot_shadow_actions.c aws_iot_shadow_json.c aws_iot_shadow_records.c
  group Middlewares/Third_Party/jsmn
    ../../../../../../Middlewares/Third_Party/jsmn/: jsmn.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/ST/STM32_Connect_Library/core
    ../../../../../../Middlewares/ST/STM32_Connect_Library/core/: net_address.c net_core.c net_os.c net_socket.c net_class_extension.c
  group Middlewares/ST/STM32_Connect_Library/services
    ../../../../../../Middlewares/ST/STM32_Connect_Library/services/: net_mbedtls.c
  group Middlewares/ST/STM32_Connect_Library/netif
    ../../../../../../Middlewares/ST/STM32_Connect_Library/netif/wifi_if/es_wifi/: net_es_wifi.c
